# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177,1035
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB\src;..\USER;..\1SYSTEM;..\0TASK;..\2Control_Algorithm;..\3Judge_System
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c
  group CORE
    ../CORE/: main.c startup_stm32f40_41xxx.s main.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../1SYSTEM/: CAN1.c CAN2.c CH040.c Motor_DJI2006.c Motor_DJI6020.c Motor_DM4310.c Timer.c USART1.c Gyroscope4Comparison.c
  group TASK
    ../0TASK/: Control_Task.c Gimbal_Task.c Fault_Diagnosis_Task.c Init_Task.c Mode_Task.c Remote_Control_Task.c Shoot_Task.c Gimbal_Task.h 00debug.h
  group Judge_System
    ../3Judge_System/: Judge_System.c VTM_Remote.c
  group Control_algorithm
    ../2Control_Algorithm/: PID.c LESO.c signal.c data_sample.c PID.h calibration_data.c
    ../../26DroneMastered/2Control_Algorithm/: gravity.h gravity.c
  group ReadMe
    ../ReadMe/: ReadMe(江文涛).txt
